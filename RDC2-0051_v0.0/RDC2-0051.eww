<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\RDC2-0051.ewp</path>
    </project>
    <batchBuild />
</workspace>
